# Keil uVision project qst_sensor.uvprojx, settings and files
target qst_sensor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qst_sensor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD USE_SW_I2C QMCX983_DREAME
  c misc: --c99
  c include: .\Firmware\CMSIS\GD\GD32F10x\Include;.\Firmware\GD32F10x_standard_peripheral\Include;.\Firmware\GD32F10x_usbd_driver\Include;.\Projects\USBD\CDC_ACM\inc;.\Utilities;.\Firmware\CMSIS;.\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYSTEM
    ./Utilities/: systick.c
    ./Projects/QST/: gd32f10x_it.c main.c
  group CMSIS
    ./Projects/QST/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ./Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group GD3210x_EVAL
    ./Utilities/: gd32f10x_eval.c
  group Startup
    ./Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group HARDWARE
    ./Hardware/src/i2c/: gd32_i2c.c gd32_sw_i2c.c
    ./Hardware/src/qmaX981/: qmaX981.c
    ./Hardware/src/fis210x/: fis210x.c fis210x_algo.c
    ./Hardware/src/usart/: bsp_usart.c
    ./Hardware/src/timer/: bsp_timer.c
    ./Hardware/src/qmcX983/: qmcX983.c qmcX983_dreame.c
    ./Hardware/src/delay/: bsp_delay.c
    ./Hardware/src/qmp6988/: qmp6988.c
